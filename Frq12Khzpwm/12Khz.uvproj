# Keil uVision project 12Khz.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: wateralarm +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER, USE_STM3210E_EVAL
  c include: .\CoreSupport;.\STM32F10x_StdPeriph_Driver\inc;.\;.\ff10a\src;.\SDIO;.\ff10a\src\option;.\modbus
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group user
    ./: stm32f10x_it.c main.c system_stm32f10x.c SERIAL.C delay.c TimerDevc.c Weightdo.c Wmeasure.c TM7711.c
    ./modbus/: GXDmodbus.c GXDmodbusEx.c
  group lib
    ./STM32F10x_StdPeriph_Driver/src/: stm32f10x_crc.c stm32f10x_iwdg.c stm32f10x_dbgmcu.c stm32f10x_wwdg.c stm32f10x_exti.c misc.c stm32f10x_bkp.c stm32f10x_rtc.c stm32f10x_pwr.c stm32f10x_cec.c stm32f10x_dac.c stm32f10x_gpio.c stm32f10x_sdio.c stm32f10x_dma.c stm32f10x_spi.c stm32f10x_fsmc.c stm32f10x_usart.c stm32f10x_can.c stm32f10x_i2c.c stm32f10x_adc.c stm32f10x_rcc.c stm32f10x_flash.c stm32f10x_tim.c
  group core
    ./CoreSupport/: core_cm3.c startup_stm32f10x_hd.s
